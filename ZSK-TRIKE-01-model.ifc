Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:18:49+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-TRIKE-01
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Оборудование благоустройства, ZSK-TRIKE-01 Тематический игровой комплекс (Транспорт) «Детская автотрасса»
In: Площадка
Description: Оборудование благоустройства. Тематический игровой комплекс (Транспорт) «Детская автотрасса»; Classification: 59.1.15.01-0532 Комплекс игровой (Классификатор строительных ресурсов (КСР))
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-TRIKE-01; ModelReference: Тематический игровой комплекс (Транспорт) «Детская автотрасса»; ProductionYear: 2026; ArticleNumber: ZSK-TRIKE-01
ORION_Изделие - Артикул: ZSK-TRIKE-01; Артикул прежний: SD-TRIKE-01; Наименование: Тематический игровой комплекс (Транспорт) «Детская автотрасса»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: По запросу; Зона безопасности: Индивидуальная; Высота свободного падения: На уровне земли; Возраст: для детей дошкольного и младшего школьного возраста; Цена: 651 280 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/transport/3013; Код КСИ: CPr>EDB080; Класс КСИ: Комплекс игровой; Коды КСР: 59.1.15.01-0532 … 59.1.15.01-0595
ADSK - ADSK_Наименование: Тематический игровой комплекс (Транспорт) «Детская автотрасса»; ADSK_Марка: ZSK-TRIKE-01; ADSK_Код изделия: 59.1.15.01-0532; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_URL страницы изделия: https://зск.рф/catalog/transport/3013
ZSK_Благоустройство - ZSK_Возрастная_группа: для детей дошкольного и младшего школьного возраста; ZSK_Зона_безопасности: Индивидуальная; ZSK_Высота_свободного_падения: На уровне земли; ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDB080; ZSK_Артикул_прежний: SD-TRIKE-01
